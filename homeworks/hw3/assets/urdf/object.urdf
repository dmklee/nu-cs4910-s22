Commit message: newly shaped object

File: homeworks/hw3/assets/urdf/object.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.007 0.04 0.02; collision box size=0.01 0.02 0.02
